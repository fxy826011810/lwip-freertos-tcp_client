# IAR project test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: PART_TM4C1294NCPDT; TARGET_IS_TM4C129_RA1
  ICCARM.CCIncludePath2: ..; ..\Main; ..\User; ..\Bsp; ..\Driver; ..\Enet; ..\Task; ..\third_party\freertos\include; ..\third_party\freertos\portable; ..\third_party\freertos\portable\IAR\ARM_CM4F; ..\third_party\lwip-1.4.1; ..\third_party\lwip-1.4.1\apps; ..\third_party\lwip-1.4.1\ports\tiva-tm4c129\include\arch; ..\third_party\lwip-1.4.1\ports\tiva-tm4c129\include\netif; ..\third_party\lwip-1.4.1\src\include\ipv4\lwip; ..\third_party\lwip-1.4.1\src\include\ipv6\lwip; ..\third_party\lwip-1.4.1\src\include\lwip; ..\third_party\lwip-1.4.1\src\include\netif; ..\third_party\lwip-1.4.1\src\include\posix; ..\third_party\lwip-1.4.1\src\include\posix\sys; ..\third_party\lwip-1.4.1\src\netif\ppp; ..\third_party\lwip-1.4.1\src\include; ..\third_party\lwip-1.4.1\test\unit; ..\third_party\lwip-1.4.1\ports\tiva-tm4c129\include; ..\third_party\lwip-1.4.1\src\include\ipv4; ..\third_party\lwip-1.4.1\src\include\ipv6; ..\third_party\lwip-1.4.1\apps\httpserver_raw
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\third_party\freertos\portable
  OBJCOPY.OOCOutputFile: test.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  group Bsp
    ../Bsp/: bsp_gpio.c bsp_i2c.c bsp_nvic.c bsp_spi.c bsp_sysctl.c bsp_timer.c bsp_uart.c
  group Driver
    ../Driver/: backplane.c lcd.c temperature.c
  group Enet
    ../Enet/: io_fs.c
  group Library
    ../Src/ewarm/: driverlib.a
  group main
    ../third_party/freertos/portable/: FreeRTOSConfig.h
    ../Main/: main.c main.h
  group Startup
    ../Startup/: startup_ewarm.c
  group Task
    ../Task/: Lwip_Task.c
  group third_party/FreeRtos/Source
    ../third_party/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group third_party/FreeRtos/Source/partable
    ../third_party/freertos/portable/MemMang/: heap_2.c
    ../third_party/freertos/portable/IAR/ARM_CM4F/: port.c portasm.s
  group third_party/lwip
    ../third_party/lwip-1.4.1/src/include/: lwipopts.h
  group third_party/lwip/app/httpserver_raw
    ../third_party/lwip-1.4.1/apps/httpserver_raw/: httpd.c
  group third_party/lwip/src/api
    ../third_party/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group third_party/lwip/src/core
    ../third_party/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_timers.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group third_party/lwip/src/core/ipv4
    ../third_party/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group third_party/lwip/src/netif
    ../third_party/lwip-1.4.1/src/netif/: etharp.c
  group User
    ../User/: tcpClient.c
  group utils
    ../utils/: locator.c lwiplib.c uartstdio.c ustdlib.c
